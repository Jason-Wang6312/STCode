# Keil uVision project STM32F103RCT6.uvprojx, settings and files
target STM32F103RCT6 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103RCT6 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\System\delay;.\System\sys;.\System\usart;.\Core;.\Main;.\Peripherals;.\STM32Lib\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Main
    ./Main/: stm32f10x_it.c system_stm32f10x.c main.c
  group Peripherals
    ./Peripherals/: oled-ssd1306.c
  group System
    ./System/delay/: delay.c
    ./System/sys/: sys.c
    ./System/usart/: usart.c
  group Core
    ./Core/: core_cm3.c startup_stm32f10x_hd.s
  group STM32F1Lib
    ./STM32Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
