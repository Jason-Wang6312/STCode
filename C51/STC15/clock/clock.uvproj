# Keil uVision project clock.uvproj, settings and files
target clock (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: clock +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: main.c ds3231.c DS18B20.C
