# Keil uVision project FM.uvproj, settings and files
target FM (MCS-51)
  device: STC15W204S STC
  cpu: IRAM(0-0xFF) IROM(0-0x0FF8) CLOCK(35000000) MODP2
  output: FM
  c flags: Optimize=8 SizeSpeed=1
  group FM
    ./: FM.c
