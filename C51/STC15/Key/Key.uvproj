# Keil uVision project Key.uvproj, settings and files
target Key (MCS-51)
  device: STC15W204S STC
  cpu: IRAM(0-0xFF) IROM(0-0x0FF8) CLOCK(35000000) MODP2
  output: Key +hex
  c flags: Optimize=8 SizeSpeed=1
  group Key
    ./: key.c
