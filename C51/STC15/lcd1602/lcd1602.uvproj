# Keil uVision project lcd1602.uvproj, settings and files
target lcd1602 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: lcd1602 +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: lcd1602.c main.c
