# Keil uVision project UartNrf24.uvproj, settings and files
target UartNrf (MCS-51)
  device: STC15W204S STC
  cpu: IRAM(0-0xFF) IROM(0-0x0FF8) CLOCK(35000000) MODP2
  output: UartNrf24 +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: mian.c
