# Keil uVision project TM1650.uvproj, settings and files
target TM1650 (MCS-51)
  device: STC15W204S STC
  cpu: IRAM(0-0xFF) IROM(0-0x0FF8) CLOCK(35000000) MODP2
  output: TM1650 +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: main.c tm16xx.c
