# Keil uVision project nrf24l01.uvproj, settings and files
target nrf24l01 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: nrf24l01 +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: main2.c
