#include "STC15F2K.H"
#include "INTRINS.h"
#include "UC1701X.h"

unsigned char code cheng1[]={
    /*-- 文字: 成 --*/
    /*-- 宋体 23; 此字体下对应的点阵为：宽 x 高=31x31 --*/
    /*-- 高度不是 8 的倍数，现调整为：宽度 x 高度=32x32 --*/
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,
    0xFC,0xFC,0x88,0x00,0x00,0x1C,0x78,0xF0,0xE0,0x00,0x80,0x80,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0xFF,0xFF,0x83,0x83,0x83,0x83,0x83,0x83,0xC3,0xC3,0x03,0x1F,
    0xFF,0xFF,0x83,0x03,0x03,0x03,0xC3,0xF3,0xF3,0x63,0x03,0x03,0x00,0x00,0x00,0x00,
    0x00,0x00,0xFC,0xFF,0x3F,0x00,0x80,0x00,0x00,0x80,0xFF,0xFF,0x03,0x00,0x00,0x03,
    0x9F,0xFF,0xF8,0xF8,0xBE,0x1F,0x07,0x01,0x00,0x00,0xE0,0x20,0x00,0x00,0x20,0x38,
    0x1F,0x07,0x01,0x00,0x00,0x01,0x01,0x07,0x07,0x23,0x31,0x18,0x0C,0x0E,0x07,0x03,
    0x01,0x01,0x01,0x03,0x07,0x0F,0x0E,0x1C,0x1F,0x3F,0x30,0x00,0x00,0x00,0x00,0x00
};

//函数声明
void DelayXms(unsigned int n);


//主函数执行
void main(){

    //初始化   
    initial_LCD();//uc1701x 显示屏初始化
 
    displayStr_5x7(0,0,"JKLMNOPQRSTUVWXYZ[\]^");
    DelayXms(600);
//    displayStr_5x7(0,0,"displayStr_5x7");
    DelayXms(600);
    displayStr_5x7(1,1,"displayStr_8x16");
    DelayXms(600);
    displayStr_8x16(4,0,"displayStr_5x7[\]^");
    DelayXms(600);
    while(1){
        
    }
}

//延时x毫秒
void DelayXms(unsigned int n)		//@12.000MHz
{
	unsigned char i, j;

    while(n--){
        _nop_();
        _nop_();
        i = 12;
        j = 168;
        do
        {
            while (--j);
        } while (--i);
    }
}

