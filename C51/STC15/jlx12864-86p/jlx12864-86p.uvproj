# Keil uVision project jlx12864-86p.uvproj, settings and files
target jlx12864-86p (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: jlx12864-86p +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: main.c UC1701X.c
