# Keil uVision project Infrared.uvproj, settings and files
target Infrared (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: Infrared
  c flags: Optimize=8 SizeSpeed=1
  group Infrared
    ./: infrared.c
