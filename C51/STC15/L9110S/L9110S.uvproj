# Keil uVision project L9110S.uvproj, settings and files
target L9110S (MCS-51)
  device: STC15W204S STC
  cpu: IRAM(0-0xFF) IROM(0-0x0FF8) CLOCK(35000000) MODP2
  output: L9110S
  c flags: Optimize=8 SizeSpeed=1
  group L9110S
    ./: L9110S.C
