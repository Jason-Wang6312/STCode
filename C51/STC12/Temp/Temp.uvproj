# Keil uVision project Temp.uvproj, settings and files
target Temp (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: Temp +hex
  c flags: Optimize=8 SizeSpeed=1
  group DS18B20
    ./: DS18B20.C LCD1602.C main.c DS1302.C
