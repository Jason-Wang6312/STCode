# Keil uVision project Nokia5110.uvproj, settings and files
target Nokia5110 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: Nokia5110 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Nokia5110
    ./: main.c nokia_5110.c
