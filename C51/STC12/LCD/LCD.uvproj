# Keil uVision project LCD.uvproj, settings and files
target LCD (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  group LCD
    ./: LCD.c main.c
