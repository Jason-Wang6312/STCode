# Keil uVision project ds18b20.uvproj, settings and files
target DS18B20 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: ds18b20 +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: DS18B20.C mian.c LCD1602.C
