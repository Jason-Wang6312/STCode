# Keil uVision project clock.uvproj, settings and files
target clock (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: clock
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: mian.c lcd1602.c ds1302.c ds18b20.c
