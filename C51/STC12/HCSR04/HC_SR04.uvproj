# Keil uVision project HC_SR04.uvproj, settings and files
target HC_SR04 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: HC_SR04 +hex
  c flags: Optimize=8 SizeSpeed=1
  group HC_SR04
    ./: HC_SR04.C LCD1602.C main.c
